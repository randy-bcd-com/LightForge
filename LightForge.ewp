# IAR project LightForge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __SAME54P20A__; F_CPU=12000000
  ICCARM.CCIncludePath2: ; config; examples; hal\include; hal\utils\include; hpl\cmcc; hpl\core; hpl\dmac; hpl\gclk; hpl\mclk; hpl\osc32kctrl; hpl\oscctrl; hpl\pm; hpl\port; hpl\ramecc; hri; ; CMSIS\Core\Include; include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAME54P20A__
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: LightForge.out
  ILINK.IlinkIcfFile: iar\iar\same54p20a_flash.icf
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __SAME54P20A__; F_CPU=12000000
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h main.c
  group src/CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group src/config
    config/: hpl_cmcc_config.h hpl_dmac_config.h hpl_gclk_config.h hpl_mclk_config.h hpl_osc32kctrl_config.h hpl_oscctrl_config.h hpl_port_config.h peripheral_clk_config.h
  group src/examples
    examples/: driver_examples.c driver_examples.h
  group src/hal/include
    hal/include/: hal_atomic.h hal_cache.h hal_delay.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hpl_cmcc.h hpl_core.h hpl_delay.h hpl_dma.h hpl_gpio.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_ramecc.h hpl_reset.h hpl_sleep.h
  group src/hal/src
    hal/src/: hal_atomic.c hal_cache.c hal_delay.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c
  group src/hal/utils/include
    hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h
  group src/hal/utils/src
    hal/utils/src/: utils_assert.c utils_event.c utils_list.c
  group src/hpl/cmcc
    hpl/cmcc/: hpl_cmcc.c
  group src/hpl/core
    hpl/core/: hpl_core_m4.c hpl_core_port.h hpl_init.c
  group src/hpl/dmac
    hpl/dmac/: hpl_dmac.c
  group src/hpl/gclk
    hpl/gclk/: hpl_gclk.c hpl_gclk_base.h
  group src/hpl/mclk
    hpl/mclk/: hpl_mclk.c
  group src/hpl/osc32kctrl
    hpl/osc32kctrl/: hpl_osc32kctrl.c
  group src/hpl/oscctrl
    hpl/oscctrl/: hpl_oscctrl.c
  group src/hpl/pm
    hpl/pm/: hpl_pm.c hpl_pm_base.h
  group src/hpl/port
    hpl/port/: hpl_gpio_base.h
  group src/hpl/ramecc
    hpl/ramecc/: hpl_ramecc.c
  group src/hri
    hri/: hri_ac_e54.h hri_adc_e54.h hri_aes_e54.h hri_can_e54.h hri_ccl_e54.h hri_cmcc_e54.h hri_dac_e54.h hri_dmac_e54.h hri_dsu_e54.h hri_e54.h hri_eic_e54.h hri_evsys_e54.h hri_freqm_e54.h hri_gclk_e54.h hri_gmac_e54.h hri_hmatrixb_e54.h hri_i2s_e54.h hri_icm_e54.h hri_mclk_e54.h hri_nvmctrl_e54.h hri_osc32kctrl_e54.h hri_oscctrl_e54.h hri_pac_e54.h hri_pcc_e54.h hri_pdec_e54.h hri_pm_e54.h hri_port_e54.h hri_qspi_e54.h hri_ramecc_e54.h hri_rstc_e54.h hri_rtc_e54.h hri_sdhc_e54.h hri_sercom_e54.h hri_supc_e54.h hri_tc_e54.h hri_tcc_e54.h hri_trng_e54.h hri_usb_e54.h hri_wdt_e54.h
  group src/iar
    iar/: system_same54.c
  group src/iar/iar
    iar/iar/: startup_same54.c
  group src/include
    include/: component-version.h sam.h same54.h same54n19a.h same54n20a.h same54p19a.h same54p20a.h system_same54.h
  group src/include/component
    include/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h picop.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
  group src/include/instance
    include/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h picop.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
  group src/include/pio
    include/pio/: same54n19a.h same54n20a.h same54p19a.h same54p20a.h
